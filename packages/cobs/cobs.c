#include "cobs.h"

/* cobs crc  */

// CRC_16高8位数据区
static const rt_uint8_t acrc_hi_lut[] = {
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
    0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,
    0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,
    0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40,
    0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,
    0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40,
    0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
    0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40,
    0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,
    0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40
};

// CRC_16低8位数据区
static const rt_uint8_t acrc_lo_lut[] = {
    0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06,
    0x07, 0xC7, 0x05, 0xC5, 0xC4, 0x04, 0xCC, 0x0C, 0x0D, 0xCD,
    0x0F, 0xCF, 0xCE, 0x0E, 0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09,
    0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9, 0x1B, 0xDB, 0xDA, 0x1A,
    0x1E, 0xDE, 0xDF, 0x1F, 0xDD, 0x1D, 0x1C, 0xDC, 0x14, 0xD4,
    0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3,
    0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3,
    0xF2, 0x32, 0x36, 0xF6, 0xF7, 0x37, 0xF5, 0x35, 0x34, 0xF4,
    0x3C, 0xFC, 0xFD, 0x3D, 0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A,
    0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38, 0x28, 0xE8, 0xE9, 0x29,
    0xEB, 0x2B, 0x2A, 0xEA, 0xEE, 0x2E, 0x2F, 0xEF, 0x2D, 0xED,
    0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26,
    0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0, 0xA0, 0x60,
    0x61, 0xA1, 0x63, 0xA3, 0xA2, 0x62, 0x66, 0xA6, 0xA7, 0x67,
    0xA5, 0x65, 0x64, 0xA4, 0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F,
    0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB, 0x69, 0xA9, 0xA8, 0x68,
    0x78, 0xB8, 0xB9, 0x79, 0xBB, 0x7B, 0x7A, 0xBA, 0xBE, 0x7E,
    0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5,
    0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71,
    0x70, 0xB0, 0x50, 0x90, 0x91, 0x51, 0x93, 0x53, 0x52, 0x92,
    0x96, 0x56, 0x57, 0x97, 0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C,
    0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E, 0x5A, 0x9A, 0x9B, 0x5B,
    0x99, 0x59, 0x58, 0x98, 0x88, 0x48, 0x49, 0x89, 0x4B, 0x8B,
    0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C,
    0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42,
    0x43, 0x83, 0x41, 0x81, 0x80, 0x40
};


rt_inline void cobs_crc_reset(crc_lut_t *crc)
{
    crc->hi_lut = 0xFF; //高CRC字节初始化
    crc->lo_lut = 0xFF; //低CRC 字节初始化
}

rt_inline rt_uint16_t cobs_crc_get(crc_lut_t *crc)
{
    //返回结果，高位在前
    return (crc->hi_lut << 8 | crc->lo_lut);
}

rt_inline void cobs_crc_one_byte(crc_lut_t *crc, rt_uint8_t byte)
{
    rt_uint8_t i =crc->lo_lut ^ byte;
   crc->lo_lut =crc->hi_lut ^ acrc_hi_lut[i];
   crc->hi_lut = acrc_lo_lut[i];
}

/* cobs decode  */

rt_inline void cobs_decode_one_byte(cobs_decode_handler_t *handler, rt_uint8_t byte)
{
    *(handler->dst)++ = byte;
    cobs_crc_one_byte(&handler->crc, byte);
}


/* 重置block,code,以及crc校验值 */
rt_inline void cobs_decode_reset(cobs_decode_handler_t *handler)
{
    handler->block = 0;
    handler->code = 0xFF;
    handler->dst = handler->buffer;
    cobs_crc_reset(&handler->crc);
}

/* set cobs complete call back */
void cobs_decode_init(cobs_decode_handler_t *handler,
                                rt_err_t (*cobs_complete)(void *buffer, rt_uint16_t size))
{
    cobs_decode_reset(handler);
    handler->cobs_complete = cobs_complete;
}

/* cobs对一段缓冲区数据进行处理, 支持数据帧分包, 分割符采用0x00
 * 收到一帧以0结尾的数据, 并且CRC16校验正确, 会调用数据解析
 * 函数 cobs_complete
 */
void cobs_decode_frame(const rt_uint8_t *src, rt_size_t length, cobs_decode_handler_t *handler)
{
    const rt_uint8_t *end = src + length;
    rt_int8_t cmd_size;

    for (; src < end; --(handler->block))
    {
        /* decode block */
        if (handler->block)
        {
            cobs_decode_one_byte(handler, *src++);
        }
        else
        {
            /* next block length */
            handler->block = *src++;

            if (handler->block != 0)
            {
                if (handler->code != 0xff)
                {
                    /* encoded zero, write it */
                    cobs_decode_one_byte(handler, 0);
                }
                handler->code = handler->block;
            }
            else
            {
                /* delimiter code found */
                cmd_size = handler->dst - handler->buffer;
                if (cmd_size >= 2)
                {
                    /* excute command */
                    if ((handler->cobs_complete != RT_NULL) && (cobs_crc_get(&handler->crc) == 0))
                    {
                        handler->cobs_complete(handler->buffer, cmd_size-2);
                    }
                }
                /* reset handler*/
                cobs_decode_reset(handler);
                handler->block = 1;
            }
        }

        if (handler->dst >= (handler->buffer + COBS_DECODE_BUF_SIZE))
        {
            /* 如果指令长度超过了指令缓冲区的最大长度则丢弃全部内容并重置变量 */
            cobs_decode_reset(handler);
            break;
        }
    }
}

/* cobs encode  */

void cobs_encode_reset(cobs_encode_handler_t *handler)
{
    handler->dst        = handler->buffer + 1;
    handler->code_ptr   = handler->buffer;
    handler->code       = 0x01;
    cobs_crc_reset(&handler->crc);
}

rt_inline void cobs_encode_end_block(cobs_encode_handler_t *handler)
{
    *(handler->code_ptr) = handler->code;
    handler->code_ptr    = handler->dst++;
    handler->code        = 0x01;
}


/*
 * StuffData byte stuffs “length” bytes of
 * data at the location pointed to by “ptr”,
 * writing the output to the location pointed
 * to by “dst”.
 */
void cobs_encode_frame(rt_uint8_t *src, rt_uint16_t length,
		cobs_encode_handler_t *handler)
{
	rt_uint8_t *end = src + length;
	while (src < end)
	{
		if (*src == 0)
        {
            cobs_crc_one_byte(&handler->crc, 0x00);
			cobs_encode_end_block(handler);
        }
		else
		{
            cobs_crc_one_byte(&handler->crc, *src);
            *(handler->dst)++ = *src;
			
			handler->code++;
			if (handler->code == 0xFF)
				cobs_encode_end_block(handler);
		}
		src++;
        if (handler->dst > handler->buffer + COBS_ENCODE_BUF_SIZE)
        {
            /* 如果数据长度超过了编码缓冲区的最大长度则丢弃全部内容并重置变量 */
            cobs_encode_reset(handler);
            rt_kprintf("encode data too long !\n");
            break;
        }
	}
}


void cobs_encode_end_frame(cobs_encode_handler_t *handler)
{
    /* 获取编码过程计算的CRC */
    rt_uint16_t _crc = cobs_crc_get(&handler->crc);
    /* 将CRC校验值编码进缓冲区 */
    cobs_encode_frame((rt_uint8_t*)&_crc, 2, handler);
    /* 添加最后一个块的长度 */
    *(handler->code_ptr) = handler->code;
    /* 添加分隔符0x00 */
    *(handler->dst)++ = 0x00;
}



# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: __FPU_PRESENT, ARM_MATH_CM4, GD32F30X_HD, USE_STDPERIPH_DRIVER, __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\extension;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;board;libraries\gd32_drivers;rt-thread\components\finsh;.;rt-thread\include;libraries\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include;libraries\GD32F30x_Firmware_Library\CMSIS;libraries\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include;packages\ad7190;packages\ad983x;packages\cobs;packages\dac7811;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;rt-thread\components\utilities\ulog;.\packages\dataprocess\Include;.\packages\motor;.\packages\detect;.\dataprocess\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Applications
    applications/: rs232_link.c main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    rt-thread/components/libc/compilers/common/: stdlib.c time.c
  group CPU
    rt-thread/libcpu/arm/common/: showmem.c backtrace.c div0.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: workqueue.c ringblk_buf.c dataqueue.c ringbuffer.c pipe.c completion.c waitqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi-bit-ops.c
  group Drivers
    libraries/GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
    board/: board.c
    libraries/gd32_drivers/: drv_gpio.c drv_soft_spi.c drv_usart.c drv_spi.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c cmd.c
  group Kernel
    rt-thread/src/: clock.c timer.c device.c kservice.c object.c mempool.c mem.c irq.c idle.c scheduler.c components.c thread.c ipc.c
  group Libraries
    libraries/GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    libraries/GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_rcu.c gd32f30x_dma.c gd32f30x_usart.c gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_spi.c
  group packages\peripherals
    packages/ad7190/: ad7190.c
    packages/ad983x/: ad983x.c
    packages/cobs/: cobs.c
    packages/dac7811/: dac7811.c
    ./packages/motor/: motor.c
    ./packages/detect/: detectctrl.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
  group LIBs
    ./packages/dataprocess/: arm_cortexM4lf_math.lib
  group DP
    ./dataprocess/src/: data_process.c filter.c gv.c
software components: CMSIS:CORE 5.5.0
